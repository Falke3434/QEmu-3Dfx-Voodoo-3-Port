## hw/display/Kconfig.fragment
```kconfig
config VOODOO3
    bool
    default y if PCI_DEVICES
    depends on PCI
    select BITBANG_I2C
    select DDC
```
